# Keil uVision project 746IG_FMC_LTDC_DMA2d.uvprojx, settings and files
target 746IG_FMC_LTDC_DMA2d (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 746IG_FMC_LTDC_DMA2d
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;                              ../Drivers/STM32F7xx_HAL_Driver/Inc;                              ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                              ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                              ../Drivers/CMSIS/Include;                              ..\STemWin\Config;                              ..\STemWin\Demo;                              ..\STemWin\inc;                              ..\STemWin\OS;                              ..\BSP;                              ../Middlewares/Third_Party/FatFs/src/drivers;                              ../Middlewares/Third_Party/FatFs/src;                              ..\STemWin\Software;                         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;                         ../Middlewares/Third_Party/FreeRTOS/Source/include;                         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c stm32f7xx_hal_msp.c main.c freertos.c crc.c dma.c dma2d.c gpio.c fmc.c ltdc.c i2c.c tim.c rng.c sdmmc.c usart.c fatfs.c bsp_driver_sd.c stm32f7xx_hal_timebase_TIM.c stm32746g_discovery_ts.c stm32746g_discovery.c ft5336.c
    ../STemWin/Software/: WindowDLG.c Window_childDLG.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dsi.c stm32f7xx_hal_pwr.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_crc.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal.c stm32f7xx_hal_tim.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_rng.c stm32f7xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group BSP
    ../BSP/: stm32746g_sdram.c
  group STemWin/Config
    ../STemWin/Config/: GUIConf.c LCDConf.c
    ../STemWin/OS/: GUI_X_OS.c
  group STemWin/Lib
    ../STemWin/Lib/: STemWin532_CM7_OS_Keil.lib
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c tasks.c queue.c timers.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.1.0
